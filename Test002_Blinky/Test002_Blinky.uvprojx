# Keil uVision project Test002_Blinky.uvprojx, settings and files
target Blinky (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test002_Blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPR_DRIVER, STM32F4XX
  c include: ..\STM32F4xx_StdPeriph_Driver;.\include;..\STM32F4xx_StdPeriph_Driver\inc;.\RTE\Device\STM32F407IGHx;..\STM32F4xx;..\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User Application
    ./src/: main.c delay.c led.c
  group User Libraries
    ./include/: delay.h led.h
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
  group STM32F4xx
    ../STM32F4xx/Include/: stm32f4xx.h
software components: CMSIS:CORE 5.0.2, Device:Startup 2.6.0
